# Keil uVision project Hoverboard.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F130C8 GigaDevice
  pack: GigaDevice.GD32F1x0_DFP.3.1.1
  cpu: IRAM(0x20000000,0x02000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Hoverboard
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: C:\Users\GauchoHP\AppData\Local\Arm\Packs\ARM\CMSIS\5.5.1\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\Objects\Hoverboard.sct
  group Src
    ./Src/: main.c bldc.c setup.c it.c comms.c commsBluetooth.c commsMasterSlave.c led.c commsActuator.c commsInterlocks.c commsSteeringPWM.c commsAccelerometer.c commsRemote.c navigator.c
  group Inc
    ./Inc/: defines.h config.h bldc.h setup.h it.h comms.h commsBluetooth.h commsMasterSlave.h led.h commsActuator.h commsInterlocks.h commsSteeringPWM.h commsAccelerometer.h commsRemote.h navigator.h
software components: CMSIS:CORE 5.1.1, Device:GD32F1x0_StdPeripherals:ADC 3.1.0, Device:GD32F1x0_StdPeripherals:DMA 3.1.0, Device:GD32F1x0_StdPeripherals:FWDGT 3.1.0, Device:GD32F1x0_StdPeripherals:GPIO 3.1.0, Device:GD32F1x0_StdPeripherals:I2C 3.1.0, Device:GD32F1x0_StdPeripherals:MCUDBG 3.1.0, Device:GD32F1x0_StdPeripherals:MISC 3.1.0, Device:GD32F1x0_StdPeripherals:OPA 3.1.0, Device:GD32F1x0_StdPeripherals:PMU 3.1.0, Device:GD32F1x0_StdPeripherals:RCU 3.1.0, Device:GD32F1x0_StdPeripherals:SYSCFG 3.1.0, Device:GD32F1x0_StdPeripherals:TIMER 3.1.0, Device:GD32F1x0_StdPeripherals:USART 3.1.0, Device:GD32F1x0_StdPeripherals:WWDGT 3.1.0, Device:GD32F1x0_libopt 3.1.0, Device:Startup 3.1.0
